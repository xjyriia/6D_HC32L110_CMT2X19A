# Keil uVision project HC32L110_RF433.uvprojx, settings and files
target 6D (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L110C6UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: APP_6D +hex
  c flags: Optim=1 OneElfS=1
  c define: BOARD_TYPE_6D
  c include: ..\mcu\common;..\source;..\driver\inc;..\config;..\CMT2119A;..\CMT2219A;..\LIS2DH
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ../mcu/common/: system_hc32l110.c
  group driver
    ../driver/src/: ddl.c interrupts_hc32l110.c clk.c gpio.c bt.c uart.c lpm.c adc.c lpt.c wdt.c flash.c adt.c lvd.c pca.c
  group app
    ../source/: main.c user_system.c
    ../config/: board.h user_common_config.h
  group CMT2119A
    ../CMT2119A/: cmt2119a.c rfm_twi.c
  group CMT2219A
    ../CMT2219A/: cmt2219a.c cmt_spi3.c cmt2219a_hal.c
  group LIS2DH
    ../LIS2DH/: lis2dh_drv.c sim_i2c.c
  group README
    ../: readme.txt
  group user_driver
    ../source/: user_flash.c user_lpt.c user_wdt.c user_lvd.c user_motor.c user_low_power.c user_vibrator.c
target RX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L110C6UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: as above
  output: APP_RX +hex
  c flags: Optim=1 OneElfS=1
  c define: BOARD_TYPE_RX
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.3.0
